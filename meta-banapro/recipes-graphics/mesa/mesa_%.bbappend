IMAGE_INSTALL:append = " \
    mesa-driver-lima \
"

PACKAGECONFIG:append = " lima"